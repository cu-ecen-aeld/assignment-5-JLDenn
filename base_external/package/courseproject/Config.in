## base_external/package/courseproject/Config.in
```kconfig
config BR2_PACKAGE_COURSEPROJECT
	bool "courseproject"
	help
	  Toolbox inventory system course project code/files
```
